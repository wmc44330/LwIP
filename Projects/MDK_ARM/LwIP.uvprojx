# Keil uVision project LwIP.uvprojx, settings and files
target LwIP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LwIP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DATA_IN_ExtSRAM,__TARGET_FPU_VFP
  c include: ..\..\Hardwares\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\User;..\..\User\Apps;..\..\Middlewares\Micrium\uC-BSP;..\..\Middlewares\Micrium\uC-CFG;..\..\Middlewares\Micrium\uC-LIB;..\..\Middlewares\Micrium\uC-CPU;..\..\Middlewares\Micrium\uC-CPU\ARM-Cortex-M4\RealView;..\..\Middlewares\Micrium\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\Middlewares\Micrium\uCOS-III\Source;..\..\Middlewares\LwIP;..\..\Middlewares\LwIP\src\include;..\..\Middlewares\LwIP\src\include\ipv4;..\..\Middlewares\LwIP\arch
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group CMSIS/Device/ST
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Cortex-M4F
    ../../Libraries/CMSIS/Include/: arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Hardwares/inc
    ../../Hardwares/inc/: led.h usart1.h phy.h
  group Hardwares/src
    ../../Hardwares/src/: led.c usart1.c phy.c
  group StdPeriphLib/inc
    ../../Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group StdPeriphLib/src
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group EthDriverLib/inc
    ../../Libraries/STM32F4x7_ETH_Driver/inc/: stm32f4x7_eth.h stm32f4x7_eth_conf.h
  group EthDriverLib/src
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Middlewares/Libc
    ../../Middlewares/Libc/: libc.c
  group Middlewares/Micrium/uC-BSP
    ../../Middlewares/Micrium/uC-BSP/: bsp.c bsp.h cpu_bsp.c
  group Middlewares/Micrium/uC-CFG
    ../../Middlewares/Micrium/uC-CFG/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group Middlewares/Micrium/uC-CPU
    ../../Middlewares/Micrium/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../Middlewares/Micrium/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group Middlewares/Micrium/uC-LIB
    ../../Middlewares/Micrium/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../Middlewares/Micrium/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group Middlewares/Micrium/uC-PORT
    ../../Middlewares/Micrium/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Middlewares/Micrium/uC-SOURCE
    ../../Middlewares/Micrium/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group User
    ../../User/: AppTaskStart.c AppTaskStart.h main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group User/Apps
    ../../User/Apps/: AppTaskLed.c AppTaskLed.h AppTaskTcpServer.c AppTaskTcpServer.h
  group Middlewares/LwIP/src/api
    ../../Middlewares/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/src/core
    ../../Middlewares/LwIP/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Middlewares/LwIP/src/core/ipv4
    ../../Middlewares/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/LwIP/src/netif
    ../../Middlewares/LwIP/src/netif/: etharp.c ethernetif.c
    ../../Middlewares/LwIP/src/include/netif/: ethernetif.h
  group Middlewares/LwIP/opts
    ../../Middlewares/LwIP/: lwipopts.h
  group Middlewares/LwIP/arch
    ../../Middlewares/LwIP/arch/: cc.h perf.h sys_arch.c sys_arch.h
